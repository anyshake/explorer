# Keil uVision project Explorer.uvprojx, settings and files
target Explorer (ARM-ADS)
  device: GD32F303CG GigaDevice
  pack: GigaDevice.GD32F30x_DFP.1.1.0
  cpu: IROM(0x08000000,0x0100000) IRAM(0x20000000,0x018000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Explorer +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_XD
  c include: .\Libraries\CMSIS\GD\GD32F30x\Include;.\Libraries\GD32F30x_standard_peripheral\Include;.\Utilities\Include;.\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ./Source/: systick.c main.c gd32f30x_it.c blink.c checksum.c serial.c spi.c delay.c
  group CMSIS
    ./Libraries/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group GD32F30x_Peripherals
    ./Libraries/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group GD32F30x_START
    ./Utilities/Source/: gd32f303c_start.c
  group Startup
    ./Libraries/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_xd.s
  group ADS1256
    ./Source/ads1256/: channel.c gain.c mode.c rw.c sample.c status.c utils.c reader.c
software components: CMSIS:CORE 4.1.0
